# Keil uVision project Lora.uvprojx, settings and files
target mlm32l07x01 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lora +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L051xx, USE_STM32L0XX_NUCLEO, USE_FULL_LL_DRIVER, REGION_CN470, USE_BOOTLOADER
  c misc: --C99
  c include: ..\..\inc;..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\Drivers\CMSIS\Include;..\..\Middlewares\Third_Party\Lora\Crypto;..\..\Middlewares\Third_Party\Lora\Mac;..\..\Middlewares\Third_Party\Lora\Phy;..\..\Middlewares\Third_Party\Lora\Utilities;..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\Middlewares\Third_Party\Lora\Core;..\..\Drivers\BSP\Components\Common;..\..\Drivers\BSP\Components\hts221;..\..\Drivers\BSP\Components\lps22hb;..\..\Drivers\BSP\Components\lps25hb;..\..\Drivers\BSP\Components\sx1276;..\..\Drivers\BSP\sx1276mb1las
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group Projects/MDK-ARM
    ./: startup_stm32l051xx.s
  group Projects/AT_Slave
    ../../src/: at.c command.c debug.c hw_gpio.c hw_rtc.c hw_spi.c lora.c main.c tiny_sscanf.c tiny_vsnprintf.c vcom.c test_rf.c stm32l0xx_hw.c stm32l0xx_it.c stm32l0xx_hal_msp.c app_fifo.c app_scheduler.c
  group Middlewares/Lora/Mac
    ../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
    ../../Middlewares/Third_Party/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
    ../../Middlewares/Third_Party/Lora/Core/: lora-test.c
  group Middlewares/Lora/Utilities
    ../../Middlewares/Third_Party/Lora/Utilities/: delay.c timeServer.c utilities.c low_power_manager.c
  group Middlewares/Lora/Crypto
    ../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
  group Drivers/BSP/sx1276mb1las
    ../../Drivers/BSP/sx1276mb1las/: sx1276mb1las.c
